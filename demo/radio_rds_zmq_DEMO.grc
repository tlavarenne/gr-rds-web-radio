options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: fichier
  id: variable_qtgui_chooser
  parameters:
    label0: 'France bleu Alsace '
    label1: France Musique
    label2: France Inter
    label3: France Inter 2
    num_opts: '4'
    option0: FranceBleu102_6_21janv2017.dat
    option1: FranceMusique91_6_21janv2017.dat
    option2: FranceInter95_7_21janv2017.dat
    option3: FranceInterALT95_7_21janv2017.dat
    type: string
    value: FranceInterALT95_7_21janv2017.dat
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.1168e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '4e-4'
    reference: '1'
    type: complex
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: fichier
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '20e-3'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/2/40/(1187.5*2)
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import binascii
      import time
      import json
      import zmq


      class blk(gr.basic_block):
          def __init__(self, tag_name="packet",
                       zmq_addr="tcp://127.0.0.1:5556",
                       print_verbose="YES"):

              gr.basic_block.__init__(
                  self,
                  name='RDS decoder',
                  in_sig=[np.uint8],
                  out_sig=[]
              )

              self.tag_name = tag_name
              self.max_block_length = 156

              self.print_verbose = (str(print_verbose).upper() == "YES")

              self.nom = [' ',' ',' ',' ',' ',' ',' ',' ']
              self.texte = ['  '] * 65

              self.capture = False
              self.byte = []
              self.start_abs = 0

              self.zmq_addr = zmq_addr
              self.zctx = zmq.Context.instance()
              self.zpub = self.zctx.socket(zmq.PUB)
              self.zpub.bind(self.zmq_addr)

              self.last_ps = ""
              self.last_rt = ""
              self.last_send = 0.0

          # ----------------------------
          # Simple character filters
          # ----------------------------
          @staticmethod
          def _ok_ps(v):
              # PS is typically uppercase + digits + space
              return (v == 0x20) or (0x30 <= v <= 0x39) or (0x41 <= v <= 0x5A)

          @staticmethod
          def _ok_rt(v):
              # RT is "free text": allow printable ASCII + Latin-1 accents
              # (reject control chars)
              return (v == 0x20) or (0x21 <= v <= 0x7E) or (0xA0 <= v <= 0xFF)

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              ninput = len(in0)

              abs0 = int(self.nitems_read(0))
              j0 = 0

              if not self.capture:
                  tags = self.get_tags_in_window(0, 0, ninput)
                  for tg in tags:
                      if tg.key == pmt.intern(self.tag_name):
                          self.start_abs = int(tg.offset)
                          j0 = self.start_abs - abs0
                          if j0 < 0:
                              j0 = 0
                          self.capture = True
                          self.byte = []
                          break

              if self.capture:
                  j = j0
                  while j < ninput and len(self.byte) < self.max_block_length:
                      self.byte.append(str(int(in0[j])))
                      j += 1

                  if len(self.byte) >= self.max_block_length:
                      trame_dec = "0"
                      i = 1
                      while i <= len(self.byte) - 2:
                          trame_dec += '0' if (self.byte[i] != self.byte[i + 1]) else '1'
                          i += 2

                      ps = ''.join(self.nom)
                      rt = ''.join(self.texte[0:64])

                      if len(trame_dec) >= 78:

                          # ---- PS (group 0) ----
                          if trame_dec[10:15] == '00000':
                              v1 = int(trame_dec[62:70], 2)
                              v2 = int(trame_dec[70:78], 2)

                              # Drop update if chars look wrong
                              if self._ok_ps(v1) and self._ok_ps(v2):
                                  c1 = bytes([v1]).decode('latin-1', errors='replace')
                                  c2 = bytes([v2]).decode('latin-1', errors='replace')

                                  seg = trame_dec[24:26]
                                  if seg == '00':
                                      self.nom[0], self.nom[1] = c1, c2
                                  if seg == '01':
                                      self.nom[2], self.nom[3] = c1, c2
                                  if seg == '10':
                                      self.nom[4], self.nom[5] = c1, c2
                                  if seg == '11':
                                      self.nom[6], self.nom[7] = c1, c2

                                  ps = ''.join(self.nom)
                                  if self.print_verbose:
                                      print(ps, flush=True)

                          # ---- RT (group 2A) ----
                          if trame_dec[10:15] == '00100':
                              vA = int(trame_dec[36:44], 2)
                              vB = int(trame_dec[44:52], 2)
                              vC = int(trame_dec[62:70], 2)
                              vD = int(trame_dec[70:78], 2)

                              # Drop update if any char looks wrong
                              if self._ok_rt(vA) and self._ok_rt(vB) and self._ok_rt(vC) and self._ok_rt(vD):
                                  A = bytes([vA]).decode('latin-1', errors='replace')
                                  B = bytes([vB]).decode('latin-1', errors='replace')
                                  C = bytes([vC]).decode('latin-1', errors='replace')
                                  D = bytes([vD]).decode('latin-1', errors='replace')

                                  indice = (
                                      int(trame_dec[22]) * 8 +
                                      int(trame_dec[23]) * 4 +
                                      int(trame_dec[24]) * 2 +
                                      int(trame_dec[25])
                                  ) * 4

                                  if 0 <= indice <= 60:
                                      self.texte[indice + 0] = A
                                      self.texte[indice + 1] = B
                                      self.texte[indice + 2] = C
                                      self.texte[indice + 3] = D

                                  rt = ''.join(self.texte[0:64])
                                  if self.print_verbose:
                                      print(rt, flush=True)

                      t = time.time()
                      if (ps != self.last_ps) or (rt != self.last_rt) or (t - self.last_send > 0.25):
                          msg = {"ps": ps, "rt": rt, "t": t}
                          try:
                              self.zpub.send_string(json.dumps(msg), flags=zmq.NOBLOCK)
                          except zmq.Again:
                              pass

                          self.last_ps = ps
                          self.last_rt = rt
                          self.last_send = t

                      self.capture = False
                      self.byte = []

              self.consume(0, ninput)
              return 0
    print_verbose: '''YES'''
    tag_name: '''packet'''
    zmq_addr: '"tcp://127.0.0.1:5556"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time, json
      import zmq

      class blk(gr.sync_block):
          def __init__(self, zmq_addr="tcp://127.0.0.1:5557", target_pts=1200, publish_hz=20):
              gr.sync_block.__init__(
                  self,
                  name="audio_scope_zmq",
                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.zmq_addr = zmq_addr
              self.target_pts = int(target_pts)
              self.publish_period = 1.0 / float(publish_hz)

              self.ctx = zmq.Context.instance()
              self.pub = self.ctx.socket(zmq.PUB)
              self.pub.bind(self.zmq_addr)

              self.buf = np.zeros(0, dtype=np.float32)
              self.last_pub = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              if x.size == 0:
                  return 0

              # accumulate
              self.buf = np.concatenate([self.buf, x.astype(np.float32, copy=False)])

              now = time.time()
              if (now - self.last_pub) >= self.publish_period:
                  # on veut envoyer ~target_pts points, décimés depuis le buffer récent
                  # on prend une fenêtre assez grande (ex: dernier 0.2 s si possible)
                  # et on sous-échantillonne pour tomber sur target_pts
                  n = self.buf.size
                  if n > 0:
                      # garde seulement les derniers échantillons (limite mémoire)
                      max_keep = 44100  # 1 s @ 44.1k (tu peux ajuster)
                      if n > max_keep:
                          self.buf = self.buf[-max_keep:]
                          n = self.buf.size

                      # sous-échantillonnage simple
                      if n >= self.target_pts:
                          step = max(1, n // self.target_pts)
                          y = self.buf[::step][:self.target_pts]
                      else:
                          y = self.buf  # pas assez, envoie ce qu’on a

                      # petite normalisation d’affichage (pas obligatoire)
                      peak = float(np.max(np.abs(y))) if y.size else 0.0
                      rms = float(np.sqrt(np.mean(y*y))) if y.size else 0.0

                      msg = {
                          "t": now,
                          "sr": 44100,              # info indicative
                          "peak": peak,
                          "rms": rms,
                          "y": y.tolist()
                      }
                      try:
                          self.pub.send_string(json.dumps(msg), flags=zmq.NOBLOCK)
                      except Exception:
                          pass

                      self.last_pub = now

              return len(x)
    publish_hz: '5'
    target_pts: '400'
    zmq_addr: '"tcp://127.0.0.1:5557"'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time, json
      import zmq

      class blk(gr.sync_block):
          def __init__(self, zmq_addr="tcp://127.0.0.1:5558",
                       in_rate=1058400.0, target_pts=1400, publish_hz=15,
                       window_ms=6.0):
              gr.sync_block.__init__(
                  self,
                  name="rds_scope_zmq",
                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.zmq_addr = zmq_addr
              self.in_rate = float(in_rate)
              self.target_pts = int(target_pts)
              self.publish_period = 1.0 / float(publish_hz)
              self.window_ms = float(window_ms)

              self.ctx = zmq.Context.instance()
              self.pub = self.ctx.socket(zmq.PUB)
              self.pub.bind(self.zmq_addr)

              self.buf = np.zeros(0, dtype=np.float32)
              self.last_pub = 0.0

              # buffer de sécurité (on garde large)
              self.max_keep = int(self.in_rate * 0.10)  # 100 ms

          def work(self, input_items, output_items):
              x = input_items[0]
              if x.size == 0:
                  return 0

              # accumulate
              self.buf = np.concatenate([self.buf, x.astype(np.float32, copy=False)])
              if self.buf.size > self.max_keep:
                  self.buf = self.buf[-self.max_keep:]

              now = time.time()
              if (now - self.last_pub) >= self.publish_period:
                  n = self.buf.size
                  if n > 16:
                      # ---- fenêtre TEMPS imposée ----
                      win_n = int(self.in_rate * (self.window_ms / 1000.0))
                      win_n = max(32, min(win_n, n))  # bornes
                      w = self.buf[-win_n:]          # segment contigu

                      # ---- décimation d'affichage dans la fenêtre ----
                      step = max(1, win_n // self.target_pts)
                      y = w[::step][:self.target_pts]

                      peak = float(np.max(np.abs(y))) if y.size else 0.0
                      rms = float(np.sqrt(np.mean(y*y))) if y.size else 0.0

                      msg = {
                          "t": now,
                          "sr": self.in_rate / step,   # "sr affiché" cohérent
                          "peak": peak,
                          "rms": rms,
                          "y": y.tolist(),
                          "window_ms": self.window_ms
                      }
                      try:
                          self.pub.send_string(json.dumps(msg), flags=zmq.NOBLOCK)
                      except Exception:
                          pass

                      self.last_pub = now

              return len(x)
    in_rate: samp_rate/2/40
    publish_hz: '5'
    target_pts: '400'
    window_ms: '12'
    zmq_addr: '"tcp://127.0.0.1:5558"'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time, json
      import zmq

      class blk(gr.sync_block):
          """
          Constellation scope web : publie un nuage I/Q (complex64) via ZMQ JSON.
          Entrée : complex64
          Sortie : aucune
          """
          def __init__(self,
                       zmq_addr="tcp://127.0.0.1:5559",
                       points=1200,
                       publish_hz=10,
                       decim=1):
              gr.sync_block.__init__(
                  self,
                  name="constellation_scope_zmq",
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.zmq_addr = zmq_addr
              self.points = int(points)
              self.publish_period = 1.0 / float(publish_hz)
              self.decim = max(1, int(decim))

              self.ctx = zmq.Context.instance()
              self.pub = self.ctx.socket(zmq.PUB)
              self.pub.bind(self.zmq_addr)

              self.buf = np.zeros(0, dtype=np.complex64)
              self.last_pub = 0.0
              self.max_keep = self.points * self.decim * 4  # marge

          def work(self, input_items, output_items):
              x = input_items[0]
              if x.size == 0:
                  return 0

              # décimation légère pour limiter la charge
              if self.decim > 1:
                  x = x[::self.decim]

              self.buf = np.concatenate([self.buf, x.astype(np.complex64, copy=False)])
              if self.buf.size > self.max_keep:
                  self.buf = self.buf[-self.max_keep:]

              now = time.time()
              if (now - self.last_pub) >= self.publish_period:
                  n = self.buf.size
                  if n >= 16:
                      N = min(self.points, n)
                      z = self.buf[-N:]

                      i = np.real(z).astype(np.float32)
                      q = np.imag(z).astype(np.float32)

                      msg = {
                          "t": now,
                          "n": int(N),
                          "i": i.tolist(),
                          "q": q.tolist()
                      }
                      try:
                          self.pub.send_string(json.dumps(msg), flags=zmq.NOBLOCK)
                      except Exception:
                          pass

                      self.last_pub = now

              return len(input_items[0])
    decim: '1'
    points: '600'
    publish_hz: '5'
    zmq_addr: '"tcp://127.0.0.1:5559"'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt


      class rds_motif_learner(gr.sync_block):
          """
          RDS motif learner based on simple statistical counting.

          - Keeps a FIFO to preserve continuity across GNU Radio buffers
          - Periodically scans a sliding window of bits
          - Extracts all 32-bit blocks from this window
          - Keeps only blocks starting with the RDS prefix (or its inverse)
          - Selects the most frequent block and publishes it as a message
          """

          def __init__(self,
                       window_bits=2500,
                       verbose=False):

              gr.sync_block.__init__(
                  self,
                  name="rds_motif_learner",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              # --- RDS fixed parameters ---
              self.P = 208                # RDS group length (samples)  --> 104 bits
              self.L = 32                 # RDS checkword length (samples) --> 16 bits (e.g F201, F405...etc.)

              self.window = int(window_bits)
              self.verbose = bool(verbose)

              # Fixed RDS prefix (normal + inverted)
              self.prefix = (0, 1, 1, 0, 0, 1, 1, 0, 1)
              self.plen = len(self.prefix)
              self.prefix_inv = tuple(1 - b for b in self.prefix)

              # Prefixes converted as integers for fast comparison in work()
              self.prefix_int = int("".join(str(b) for b in self.prefix), 2)
              self.prefix_inv_int = int("".join(str(b) for b in self.prefix_inv), 2)

              # Mask to keep exactly 32 bits when packing
              self.mask = (1 << self.L) - 1

              # Message output port: send detected code ("0101...")
              self.port_out = pmt.intern("code")
              self.message_port_register_out(self.port_out)

              # Internal state
              self.fifo = []              # bit history
              self.since_scan = 0         # counter since last scan
              self.last_sent = None       # last emitted motif (anti-spam)

              # Maximum FIFO size (window + margin + motif)
              self.keep = self.window + 5*self.P + self.L

          def _emit_int(self, code_int, score):
              """
              Convert an integer motif to a 32-bit binary string
              and publish it on the message port.
              """
              bits = format(code_int, "032b")
              self.message_port_pub(self.port_out, pmt.intern(bits))
              self.last_sent = code_int
              if self.verbose:
                  print(f"[learner] best={bits} score={score}")

          def work(self, input_items, output_items):
              # Pass-through of the input bitstream
              y = output_items[0]
              y[:] = input_items[0]
              n = len(y)

              # Push new bits into the FIFO
              self.fifo.extend(int(b) for b in y)
              if len(self.fifo) > self.keep:
                  self.fifo = self.fifo[-self.keep:]

              # Scan only every window_bits
              self.since_scan += n
              if self.since_scan < self.window:
                  return n
              self.since_scan = 0

              fifo = self.fifo

              # Not enough data
              if len(fifo) < self.L:
                  return n

              # Maximum number of motifs to test in the window
              scan_max = min(len(fifo) - self.L + 1, self.window)
              if scan_max <= 0:
                  return n

              # Rolling 32-bit packing into integers
              code_int = 0
              for i in range(self.L):
                  code_int = ((code_int << 1) | fifo[i]) & self.mask

              codes = [0] * scan_max
              codes[0] = code_int
              for s in range(1, scan_max):
                  code_int = ((code_int << 1) & self.mask) | fifo[s + self.L - 1]
                  codes[s] = code_int

              # Count occurrences with prefix filtering
              scores = {}
              shift_prefix = self.L - self.plen

              for a in codes:
                  head = a >> shift_prefix
                  if head != self.prefix_int and head != self.prefix_inv_int:
                      continue
                  scores[a] = scores.get(a, 0) + 1

              if not scores:
                  return n

              # Select the most frequent motif
              best = max(scores, key=scores.get)

              # Emit only if it changed
              if best != self.last_sent:
                  self._emit_int(best, scores[best])

              return n
    verbose: 'False'
    window_bits: '3000'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt
      from collections import deque


      class RDS_correlate_access_code_tag(gr.sync_block):
          """
          correlator with dynamic access code for RDS stream.

          - Input: stream of 0/1 bits (uint8)
          - Code provided via message ("0101...")
          - Detection using a sliding window
          - A tag is placed just after the last bit of the detected pattern
          - Both the code and its inverse are detected (phase inversion)

          """

          def __init__(self, tag_name="packet"):
              gr.sync_block.__init__(
                  self,
                  name="RDS_correlate_access_code_tag",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_name)

              # Message input port to receive the access code
              self.port_in = pmt.intern("set_code")
              self.message_port_register_in(self.port_in)
              self.set_msg_handler(self.port_in, self._set_code)

              self.code = None          # access code as a list of 0/1 bits
              self.code_inv = None      # binary inverse of the code
              self.shift = deque()      # shift register

          def _set_code(self, msg):
              # Convert PMT message to Python string
              if pmt.is_symbol(msg):
                  s = pmt.symbol_to_string(msg)
              elif pmt.is_string(msg):
                  s = pmt.string_to_python(msg)
              else:
                  s = pmt.write_string(msg)

              # Keep only '0' and '1' characters
              code = [1 if c == "1" else 0 for c in s]
              if len(code) < 2:
                  return

              self.code = code
              self.code_inv = [1 - b for b in code]
              self.shift = deque(maxlen=len(code))  # reset and set proper length

          def work(self, input_items, output_items):
              y = output_items[0]
              y[:] = input_items[0]

              n = len(y)
              abs_out0 = int(self.nitems_written(0))  # Absolute output offset

              if self.code is None:
                  return n

              code = self.code
              inv = self.code_inv
              L = len(code)

              for i in range(n):
                  # Update the sliding window
                  self.shift.append(int(y[i]))

                  # Check for exact match with code or its inverse
                  if len(self.shift) == L:
                      w = list(self.shift)
                      if w == code or w == inv:
                          # Tag position: just after the last bit of the pattern
                          t = abs_out0 + i + 1
                          self.add_item_tag(0, t, self.tag_key, pmt.from_long(0))

              return n
    tag_name: '''packet'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '57000'
    decim: '20'
    samp_rate: samp_rate/4
    taps: firdes.low_pass(1,samp_rate/4,3000,500,window.WIN_HAMMING)
    type: fcc
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 16e3
    decim: '12'
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_wfm_rcv_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_wfm_rcv_0_0, '0', low_pass_filter_0_1, '0']
- [blocks_complex_to_arg_0_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_real_0, '0', epy_block_2, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_4, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_rcv_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_arg_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_3, '0']
- [epy_block_4, '0', epy_block_6, '0']
- [epy_block_4, code, epy_block_6, set_code]
- [epy_block_6, '0', epy_block_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_1, '0', audio_sink_0, '0']
- [low_pass_filter_0_1, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
